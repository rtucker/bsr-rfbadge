<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>decode</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>hb</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>deci</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>scalef</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>decode_blk</key>
<param><key>id</key><value>decode_blk_0</value></param>
<param><key>avg</key><value>deci</value></param>
<param><key>freq</key><value>freq_1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>scalef</key><value>scalef*2</value></param>
</block>
<block>
<key>decode_blk</key>
<param><key>id</key><value>decode_blk_0_0</value></param>
<param><key>avg</key><value>deci</value></param>
<param><key>freq</key><value>freq_2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>scalef</key><value>scalef*20</value></param>
</block>
<block>
<key>decode_blk</key>
<param><key>id</key><value>decode_blk_0_1</value></param>
<param><key>avg</key><value>deci</value></param>
<param><key>freq</key><value>freq_3</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>scalef</key><value>scalef*4</value></param>
</block>
<block>
<key>decode_blk</key>
<param><key>id</key><value>decode_blk_0_2</value></param>
<param><key>avg</key><value>deci</value></param>
<param><key>freq</key><value>freq_4</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>scalef</key><value>scalef</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_1</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>503</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_2</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1009</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_3</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2003</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_4</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>4001</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>f1</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>f2</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>f3</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_3</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>f4</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>0</value></param>
</block>
<connection><source_block_id>decode_blk_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>decode_blk_0_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>decode_blk_0_1</source_block_id><sink_block_id>pad_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>decode_blk_0_2</source_block_id><sink_block_id>pad_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>decode_blk_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>decode_blk_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>decode_blk_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>decode_blk_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
