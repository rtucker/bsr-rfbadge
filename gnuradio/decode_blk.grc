<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>decode_blk</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>hb</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hi_mult</value></param>
<param><key>value</key><value>1.1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>low_mult</value></param>
<param><key>value</key><value>0.9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>trans</value></param>
<param><key>value</key><value>0.1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>avg</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>2</value></param>
<param><key>high_cutoff_freq</key><value>hi_mult*freq</value></param>
<param><key>low_cutoff_freq</key><value>low_mult*freq</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>trans*freq</value></param>
<param><key>win</key><value>firdes.WIN_BLACKMAN</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>scalef</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>band_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
